## boards/shields/heptapaw/Kconfig.defconfig
```kconfig
if SHIELD_HEPTAPAW

  config ZMK_KEYBOARD_NAME
    default "heptapaw"
    
endif
```
